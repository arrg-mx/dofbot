Commit message: Updated dofbot_arm.urdf, added base_link inertial values (noetic-devel).

File: dofbot_description/urdf/dofbot_arm.urdf (robot description, URDF)
Before this commit: robot dofbot_arm, 13 links, 12 joints
Links:
- link base_link: mass None -> 1.0754239466482
